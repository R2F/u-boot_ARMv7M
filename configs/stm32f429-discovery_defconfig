## configs/stm32f429-discovery_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_STM32F429_DISCOVERY=y
CONFIG_SYS_EXTRA_OPTIONS="ARMV7M"
```
